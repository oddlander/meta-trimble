
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/files:"

SRC_URI += "file://zynq-zc702-usb0-device.patch"
