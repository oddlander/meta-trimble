FILESEXTRAPATHS_prepend := "${THISDIR}/cfgfiles:"

SRC_URI += " \
file://lsusb.cfg \
file://modinfo.cfg \
"
